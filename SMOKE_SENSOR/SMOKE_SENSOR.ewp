# IAR project SMOKE_SENSOR.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG22C224F512IM32 SiliconLaboratories EFR32MG22C224F512IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NULL_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES2_CONFIG2_MICRO; EFR32MG22; EFR32MG22C224F512IM32; ATTRIBUTE_STORAGE_CONFIGURATION="SMOKE_SENSOR_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="SMOKE_SENSOR_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="SMOKE_SENSOR.h"; __SOURCEFILE__="$FILE_FNAME$"; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; MBEDTLS_CONFIG_FILE="mbedtls-config-generated.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; SL_CATALOG_POWER_MANAGER_PRESENT; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_AF_API_NEIGHBOR_HEADER="stack/include/stack-info.h"; EMBER_STACK_ZIGBEE; APPLICATION_TOKEN_HEADER="znet-token.h"; APPLICATION_MFG_TOKEN_HEADER="znet-mfg-token.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_FILE="config-device-acceleration.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_APP_FILE="config-device-acceleration-app.h"; NVM3_FLASH_PAGES=4; NVM3_DEFAULT_CACHE_SIZE=200; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\developer\sdks\gecko_sdk_suite\v3.2; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\..\..; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\..\..\stack; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\..\util; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\plugin; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\CMSIS\Include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG22\Include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\common\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\service\sleeptimer\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\service\sleeptimer\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\common\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emlib\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\middleware\glib; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\middleware\glib\glib; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\radio\mac; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\halconfig\inc\hal-config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\hardware\module\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\hardware\kit\common\halconfig; ..\..\developer\sdks\gecko_sdk_suite\v3.2\hardware\kit\common\bsp; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\config\segger; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\emdrv\nvm3\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\common; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\coexistence\common; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\pa-conversions; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\protocol\ble; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\protocol\ieee802154; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\protocol\zwave; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\hfxo_manager\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\mpu\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\power_manager\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\sleeptimer\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\sleeptimer\src; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\common\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\mac; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\silicon_labs\silabs_core; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\plugin\plugin-common\mbedtls; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\include\mbedtls; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\include\psa; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\library; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\se_manager\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\se_manager\src; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_alt\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_cryptoacc_library\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_mbedtls_support\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_mbedtls_support\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_protocol_crypto\src; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_psa_driver\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\segger\systemview\SEGGER; hal-config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES2_CONFIG2_MICRO; EFR32MG22; EFR32MG22C224F512IM32; ATTRIBUTE_STORAGE_CONFIGURATION="SMOKE_SENSOR_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="SMOKE_SENSOR_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="SMOKE_SENSOR.h"; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; MBEDTLS_CONFIG_FILE="mbedtls-config-generated.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; SL_CATALOG_POWER_MANAGER_PRESENT; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_AF_API_NEIGHBOR_HEADER="stack/include/stack-info.h"; EMBER_STACK_ZIGBEE; APPLICATION_TOKEN_HEADER="znet-token.h"; APPLICATION_MFG_TOKEN_HEADER="znet-mfg-token.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_FILE="config-device-acceleration.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_APP_FILE="config-device-acceleration-app.h"; NVM3_FLASH_PAGES=4; NVM3_DEFAULT_CACHE_SIZE=200; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\developer\sdks\gecko_sdk_suite\v3.2; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\..\..; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\..\..\stack; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\..\util; ..\..\developer\sdks\gecko_sdk_suite\v3.2\protocol\zigbee\app\framework\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\plugin; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\CMSIS\Include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG22\Include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\common\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\service\sleeptimer\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\service\sleeptimer\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\common\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\emlib\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\middleware\glib; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\middleware\glib\glib; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\halconfig\inc\hal-config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\hardware\kit\common\halconfig; ..\..\developer\sdks\gecko_sdk_suite\v3.2\hardware\kit\common\bsp; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\config\segger; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\emdrv\nvm3\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\common; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\coexistence\common; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\plugin\pa-conversions; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\protocol\ble; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\protocol\ieee802154; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\rail_lib\protocol\zwave; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\hfxo_manager\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\mpu\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\power_manager\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\sleeptimer\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\service\sleeptimer\src; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\common\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\radio\mac; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\silicon_labs\silabs_core; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\plugin\plugin-common\mbedtls; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\include\mbedtls; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\include\psa; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\mbedtls\library; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\se_manager\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\se_manager\src; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_alt\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_cryptoacc_library\include; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_mbedtls_support\config; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_mbedtls_support\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_protocol_crypto\src; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\crypto\sl_component\sl_psa_driver\inc; ..\..\developer\sdks\gecko_sdk_suite\v3.2\util\third_party\segger\systemview\SEGGER; hal-config
  OBJCOPY.OOCOutputFile: SMOKE_SENSOR.s37
  prebuild: SMOKE_SENSOR-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'D:\v5'
  postbuild: SMOKE_SENSOR-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'D:\v5'
  ILINK.IlinkOutputFile: SMOKE_SENSOR.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=524288; RAM_SIZE=32768; FLASH_PAGE_SIZE=8192; SIMEEPROM_SIZE=32768; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HEADER_SIZE=512; BTL_SIZE=24576; NULL_BTL=1; EMBER_MALLOC_HEAP_SIZE=0
  ILINK.IlinkIcfFile: ..\..\developer\sdks\gecko_sdk_suite\v3.2\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SMOKE_SENSOR_callbacks.c znet-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c znet-cli.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/emdrv/uartdrv/src/: uartdrv.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/plugin/adc/: adc-efr32.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/basic/: basic.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/plugin/plugin-common/battery-monitor/: battery-monitor-efr32.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/stack/framework/: ccm-star.c strong-random-api.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c coulomb-counter-802154.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/segger/systemview/SEGGER/: SEGGER_RTT.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/plugin/debug-jtag-stub/: debug-jtag-stub.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/diagnostic-server/: diagnostic-server-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/end-device-support/: end-device-support.c end-device-move.c end-device-support-cli.c polling-common.c polling-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/plugin/plugin-common/generic-interrupt-control/: generic-interrupt-control-efr32.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/service/hfxo_manager/src/: sl_hfxo_manager.c sl_hfxo_manager_hal_s2.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/radio/rail_lib/plugin/pa-conversions/: pa_conversions_efr32.c pa_curves_efr32.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/micro/cortexm3/efm32/: hal-config.c hal-config-gpio.c assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep-efm32.c token.c ext-device.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/service/mpu/src/: sl_mpu.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/service/power_manager/src/: sl_power_manager.c sl_power_manager_debug.c sl_power_manager_hal_s0_s1.c sl_power_manager_hal_s2.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/common/src/: sl_slist.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/ias-zone-server/: ias-zone-server.c ias-zone-server-cli.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin-soc/idle-sleep/: idle-sleep.c idle-sleep-cli.c idle-sleep-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/manufacturing-library-cli/: manufacturing-library-cli-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/sl_component/sl_cryptoacc_library/src/: ba414ep_config.c ba431_config.c cryptodma_internal.c cryptolib_types.c sx_aes.c sx_blk_cipher.c sx_dh_alg.c sx_ecc_curves.c sx_ecc_keygen_alg.c sx_ecdsa_alg.c sx_hash.c sx_math.c sx_memcmp.c sx_memcpy.c sx_primitives.c sx_rng.c sx_trng.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/sl_component/se_manager/src/: sl_se_manager.c sl_se_manager_attestation.c sl_se_manager_cipher.c sl_se_manager_entropy.c sl_se_manager_hash.c sl_se_manager_key_derivation.c sl_se_manager_key_handling.c sl_se_manager_signature.c sl_se_manager_util.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/sl_component/sl_alt/source/: sl_entropy.c sl_mbedtls.c sl_psa_its_nvm3.c sl_se_management.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/sl_component/sl_mbedtls_support/src/: aes_aes.c crypto_aes.c crypto_ecp.c crypto_gcm.c cryptoacc_aes.c cryptoacc_gcm.c mbedtls_ccm.c mbedtls_cmac.c mbedtls_ecdsa_ecdh.c mbedtls_sha.c se_aes.c se_gcm.c se_jpake.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/sl_component/sl_protocol_crypto/src/: sli_protocol_crypto_crypto.c sli_protocol_crypto_radioaes.c sli_radioaes_management.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/sl_component/sl_psa_driver/src/: crypto_management.c cryptoacc_management.c sli_crypto_transparent_driver_aead.c sli_crypto_transparent_driver_cipher.c sli_crypto_transparent_driver_hash.c sli_crypto_transparent_driver_mac.c sli_crypto_trng_driver.c sli_cryptoacc_transparent_driver_aead.c sli_cryptoacc_transparent_driver_cipher.c sli_cryptoacc_transparent_driver_hash.c sli_cryptoacc_transparent_driver_key_derivation.c sli_cryptoacc_transparent_driver_key_management.c sli_cryptoacc_transparent_driver_mac.c sli_cryptoacc_transparent_driver_signature.c sli_psa_driver_common.c sli_psa_driver_ghash.c sli_psa_driver_init.c sli_psa_trng.c sli_se_driver_aead.c sli_se_driver_builtin_keys.c sli_se_driver_cipher.c sli_se_driver_key_derivation.c sli_se_driver_key_management.c sli_se_driver_mac.c sli_se_driver_signature.c sli_se_opaque_driver_aead.c sli_se_opaque_driver_cipher.c sli_se_opaque_driver_mac.c sli_se_opaque_key_derivation.c sli_se_transparent_driver_aead.c sli_se_transparent_driver_cipher.c sli_se_transparent_driver_hash.c sli_se_transparent_driver_mac.c sli_se_transparent_key_derivation.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/util/third_party/crypto/mbedtls/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c des.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c error.c gcm.c md.c md5.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform_util.c poly1305.c psa_crypto.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_slot_management.c psa_crypto_storage.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/network-steering/: network-steering.c network-steering-cli.c network-steering-v2.c network-steering-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/emdrv/nvm3/src/: nvm3_lock.c nvm3_default.c nvm3_hal_flash.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin-soc/power-configuration-server/: power-configuration-server.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/reporting/: reporting.c reporting-cli.c reporting-default-configuration.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/simple-main/: simple-main.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/plugin/update-tc-link-key/: update-tc-link-key.c update-tc-link-key-cli.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/util/: af-event.c af-main-common.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c time-util.c util.c af-main-soc.c service-discovery-soc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/../util/serial/: command-interpreter2.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/../../stack/config/: ember-configuration.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/../util/common/: library.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/../util/security/: security-address-cache.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/: ember-base-configuration.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/app/framework/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_rtcc.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_eusart.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/base/hal/../../Device/SiliconLabs/EFR32MG22/Source/: system_efr32mg22.c
  group Libraries
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg22-rail/: binding-table-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg22-rail/: cbke-163k1-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg22-rail/: cbke-283k1-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg22-rail/: cbke-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg22-rail/: cbke-library-dsa-sign-stub.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg22-rail/: cbke-library-dsa-verify-stub.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg22-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/debug-basic-library-cortexm3-iar-efr32mg22-rail/: debug-basic-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/debug-extended-stub-library-cortexm3-iar-efr32mg22-rail/: debug-extended-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/end-device-bind-stub-library-cortexm3-iar-efr32mg22-rail/: end-device-bind-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/gp-stub-library-cortexm3-iar-efr32mg22-rail/: gp-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg22-rail/: hal-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg22-rail/: install-code-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/mfglib-library-cortexm3-iar-efr32mg22-rail/: mfglib-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-efr32mg22-rail/: multi-network-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/multi-pan-stub-library-cortexm3-iar-efr32mg22-rail/: multi-pan-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/emdrv/nvm3/lib/: libnvm3_CM33_iar.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/packet-validate-library-cortexm3-iar-efr32mg22-rail/: packet-validate-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg22_iar_release.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/security-library-link-keys-stub-cortexm3-iar-efr32mg22-rail/: security-library-link-keys-stub.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/sim-eeprom2-to-nvm3-upgrade-stub-library-cortexm3-iar-efr32mg22-rail/: sim-eeprom2-to-nvm3-upgrade-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/source-route-stub-library-cortexm3-iar-efr32mg22-rail/: source-route-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-efr32mg22-rail/: zigbee-pro-stack.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg22-rail/: zigbee-r22-support-stub-library.a
    ../../developer/sdks/gecko_sdk_suite/v3.2/protocol/zigbee/build/zll-stub-library-cortexm3-iar-efr32mg22-rail/: zll-stub-library.a
